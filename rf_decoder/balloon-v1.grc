options:
  parameters:
    generate_options: qt_gui
    id: balloon_1
    output_language: python
    title: Balloon Decoder v1
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    ok_to_block: 'False'
    samp_rate: '44100'
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: '10'
    samp_rate: samp_rate
    subaudio: 'False'
  states: {}

connections:
- [audio_source_0, '0', blocks_throttle2_0_0, '0']
- [blocks_throttle2_0_0, '0', satellites_fsk_demodulator_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
